v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -80 20 3 0 {name=p1 lab=D3}
C {devices/ipin.sym} -40 20 3 0 {name=p2 lab=D2}
C {devices/ipin.sym} 0 20 3 0 {name=p3 lab=D1}
C {devices/ipin.sym} 40 20 3 0 {name=p4 lab=D0}
C {devices/ipin.sym} -110 -10 0 0 {name=p5 lab=I_IN}
C {devices/opin.sym} 70 -30 0 0 {name=p6 lab=I_OUT}
C {devices/opin.sym} 70 0 0 0 {name=p7 lab=I_DUMP}
