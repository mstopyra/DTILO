v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -430 20 -400 20 {
lab=#net1}
N -340 20 -310 20 {
lab=#net1}
N -250 20 -220 20 {
lab=#net1}
N -160 20 -130 20 {
lab=#net1}
N -70 20 -40 20 {
lab=#net1}
N 20 20 50 20 {
lab=#net1}
N 110 20 140 20 {
lab=#net1}
N -410 -10 -410 20 {
lab=#net1}
N -320 -10 -320 20 {
lab=#net1}
N -230 -10 -230 20 {
lab=#net1}
N -140 -10 -140 10 {
lab=#net1}
N -140 10 -140 20 {
lab=#net1}
N -50 -10 -50 20 {
lab=#net1}
N 40 -10 40 20 {
lab=#net1}
N 130 -10 130 20 {
lab=#net1}
N -100 -60 -10 -60 {
lab=VBN}
N -70 -90 -40 -90 {
lab=GND}
N -50 -90 -50 -40 {
lab=GND}
N -50 -40 200 -40 {
lab=GND}
N -160 -90 -160 -40 {
lab=GND}
N -160 -40 -50 -40 {
lab=GND}
N -10 -60 20 -60 {
lab=VBN}
N 20 -90 20 -60 {
lab=VBN}
N -50 -150 -10 -150 {
lab=VBP}
N -10 -160 -10 -150 {
lab=VBP}
N 20 -60 210 -60 {
lab=VBN}
N -10 -150 210 -150 {
lab=VBP}
N -280 -150 -50 -150 {
lab=VBP}
N -280 -160 -280 -150 {
lab=VBP}
N -130 -150 -130 -90 {
lab=VBP}
N 20 -190 20 -90 {
lab=VBN}
N -190 -160 -100 -160 {
lab=#net2}
N -70 -190 -70 -150 {
lab=VBP}
N -40 -220 -40 -190 {
lab=VDD}
N -310 -190 -310 -60 {
lab=#net1}
N -490 -60 -310 -60 {
lab=#net1}
N -490 -60 -490 20 {
lab=#net1}
N -160 -190 -130 -190 {
lab=VDD}
N -220 -160 -190 -160 {
lab=#net2}
N -220 -190 -220 -160 {
lab=#net2}
N -250 -220 -250 -190 {
lab=VDD}
N -250 -220 -40 -220 {
lab=VDD}
N -150 -220 -150 -190 {
lab=VDD}
N 210 20 230 20 {
lab=GND}
N 200 20 210 20 {
lab=GND}
N 210 -40 210 20 {
lab=GND}
N 200 -40 210 -40 {
lab=GND}
N -220 -160 -220 -90 {
lab=#net2}
N -190 -60 -190 -20 {
lab=#net1}
N -190 -20 -190 -10 {
lab=#net1}
N -460 -20 -370 -20 {
lab=#net1}
N -370 -20 170 -20 {
lab=#net1}
N -470 -20 -460 -20 {
lab=#net1}
N -490 -20 -470 -20 {
lab=#net1}
N -460 -20 -460 -10 {
lab=#net1}
N -410 -20 -410 -10 {
lab=#net1}
N -370 -20 -370 -10 {
lab=#net1}
N -320 -20 -320 -10 {
lab=#net1}
N -280 -20 -280 -10 {
lab=#net1}
N -230 -20 -230 -10 {
lab=#net1}
N -140 -20 -140 -10 {
lab=#net1}
N -100 -20 -100 -10 {
lab=#net1}
N -50 -20 -50 -10 {
lab=#net1}
N -10 -20 -10 -10 {
lab=#net1}
N 40 -20 40 -10 {
lab=#net1}
N 80 -20 80 -10 {
lab=#net1}
N 130 -20 130 -10 {
lab=#net1}
N 170 -20 170 -10 {
lab=#net1}
N 860 20 890 20 {
lab=#net3}
N 770 20 800 20 {
lab=#net3}
N 680 20 710 20 {
lab=#net3}
N 590 20 620 20 {
lab=#net3}
N 500 20 530 20 {
lab=#net3}
N 410 20 440 20 {
lab=#net3}
N 320 20 350 20 {
lab=#net3}
N 870 -10 870 20 {
lab=#net3}
N 780 -10 780 20 {
lab=#net3}
N 690 -10 690 20 {
lab=#net3}
N 600 -10 600 10 {
lab=#net3}
N 600 10 600 20 {
lab=#net3}
N 510 -10 510 20 {
lab=#net3}
N 420 -10 420 20 {
lab=#net3}
N 330 -10 330 20 {
lab=#net3}
N 470 -60 560 -60 {
lab=VBN}
N 500 -90 530 -90 {
lab=GND}
N 510 -90 510 -40 {
lab=GND}
N 260 -40 510 -40 {
lab=GND}
N 620 -90 620 -40 {
lab=GND}
N 510 -40 620 -40 {
lab=GND}
N 440 -60 470 -60 {
lab=VBN}
N 440 -90 440 -60 {
lab=VBN}
N 470 -150 510 -150 {
lab=VBP}
N 470 -160 470 -150 {
lab=VBP}
N 250 -60 440 -60 {
lab=VBN}
N 250 -150 470 -150 {
lab=VBP}
N 510 -150 740 -150 {
lab=VBP}
N 740 -160 740 -150 {
lab=VBP}
N 590 -150 590 -90 {
lab=VBP}
N 440 -190 440 -90 {
lab=VBN}
N 560 -160 650 -160 {
lab=#net4}
N 530 -190 530 -150 {
lab=VBP}
N 500 -220 500 -190 {
lab=VDD}
N 770 -190 770 -60 {
lab=#net3}
N 770 -60 950 -60 {
lab=#net3}
N 950 -60 950 20 {
lab=#net3}
N 590 -190 620 -190 {
lab=VDD}
N 650 -160 680 -160 {
lab=#net4}
N 680 -190 680 -160 {
lab=#net4}
N 710 -220 710 -190 {
lab=VDD}
N 500 -220 710 -220 {
lab=VDD}
N 610 -220 610 -190 {
lab=VDD}
N 230 20 250 20 {
lab=GND}
N 250 20 260 20 {
lab=GND}
N 250 -40 250 20 {
lab=GND}
N 250 -40 260 -40 {
lab=GND}
N 680 -160 680 -90 {
lab=#net4}
N 650 -60 650 -20 {
lab=#net3}
N 650 -20 650 -10 {
lab=#net3}
N 830 -20 920 -20 {
lab=#net3}
N 290 -20 830 -20 {
lab=#net3}
N 920 -20 930 -20 {
lab=#net3}
N 930 -20 950 -20 {
lab=#net3}
N 920 -20 920 -10 {
lab=#net3}
N 870 -20 870 -10 {
lab=#net3}
N 830 -20 830 -10 {
lab=#net3}
N 780 -20 780 -10 {
lab=#net3}
N 740 -20 740 -10 {
lab=#net3}
N 690 -20 690 -10 {
lab=#net3}
N 600 -20 600 -10 {
lab=#net3}
N 560 -20 560 -10 {
lab=#net3}
N 510 -20 510 -10 {
lab=#net3}
N 470 -20 470 -10 {
lab=#net3}
N 420 -20 420 -10 {
lab=#net3}
N 380 -20 380 -10 {
lab=#net3}
N 330 -20 330 -10 {
lab=#net3}
N 290 -20 290 -10 {
lab=#net3}
N 230 20 230 30 {
lab=GND}
N 210 -60 250 -60 {
lab=VBN}
N 210 -150 250 -150 {
lab=VBP}
N 240 -270 240 -150 {
lab=VBP}
N 310 -270 310 -60 {
lab=VBN}
N -330 -190 -310 -190 {
lab=#net1}
N -390 -220 -360 -220 {
lab=VDD}
N -390 -220 -390 -190 {
lab=VDD}
N 770 -190 790 -190 {
lab=#net3}
N 820 -220 850 -220 {
lab=VDD}
N 850 -220 850 -190 {
lab=VDD}
N -230 -90 -220 -90 {
lab=#net2}
N -290 -90 -290 -60 {
lab=GND}
N -290 -60 -260 -60 {
lab=GND}
N 680 -90 690 -90 {
lab=#net4}
N 750 -90 750 -60 {
lab=GND}
N 720 -60 750 -60 {
lab=GND}
N 950 20 960 20 {
lab=#net4}
N 1020 20 1020 50 {
lab=GND}
N 990 50 1020 50 {
lab=GND}
N -500 20 -490 20 {
lab=#net4}
N -560 20 -560 50 {
lab=GND}
N -560 50 -530 50 {
lab=GND}
C {madvlsi/nmos3.sym} -460 20 1 0 {name=M1
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -370 20 1 0 {name=M2
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -280 20 1 0 {name=M3
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -190 20 1 0 {name=M4
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -100 20 1 0 {name=M5
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -10 20 1 0 {name=M6
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 80 20 1 0 {name=M7
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 170 20 1 0 {name=M8
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -10 -90 3 0 {name=M9
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -100 -90 3 0 {name=M10
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -190 -90 3 0 {name=M11
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -10 -190 3 0 {name=M12
L=32
W=4
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -100 -190 3 0 {name=M13
L=32
W=4
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -190 -190 3 0 {name=M14
L=32
W=4
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -280 -190 3 0 {name=M15
L=32
W=4
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} -150 -220 0 0 {name=l3 lab=VDD}
C {madvlsi/gnd.sym} 230 30 0 0 {name=l4 lab=GND}
C {madvlsi/nmos3.sym} 920 20 3 1 {name=M16
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 830 20 3 1 {name=M17
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 740 20 3 1 {name=M18
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 650 20 3 1 {name=M19
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 560 20 3 1 {name=M20
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 470 20 3 1 {name=M21
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 380 20 3 1 {name=M22
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 290 20 3 1 {name=M23
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 470 -90 1 1 {name=M24
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 560 -90 1 1 {name=M25
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 650 -90 1 1 {name=M26
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 470 -190 1 1 {name=M27
L=32
W=4
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 560 -190 1 1 {name=M28
L=32
W=4
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 650 -190 1 1 {name=M29
L=32
W=4
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 740 -190 1 1 {name=M30
L=32
W=4
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 610 -220 0 1 {name=l1 lab=VDD}
C {devices/opin.sym} 240 -270 3 0 {name=p1 lab=VBP}
C {devices/opin.sym} 310 -270 3 0 {name=p15 lab=VBN}
C {madvlsi/pmos3.sym} -360 -190 1 0 {name=M31
L=32
W=4
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} -390 -220 0 0 {name=l2 lab=VDD}
C {madvlsi/pmos3.sym} 820 -190 3 1 {name=M32
L=32
W=4
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/vdd.sym} 850 -220 0 1 {name=l5 lab=VDD}
C {madvlsi/nmos3.sym} -260 -90 3 0 {name=M33
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} -260 -60 0 0 {name=l6 lab=GND}
C {madvlsi/nmos3.sym} 720 -90 1 1 {name=M34
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 720 -60 0 1 {name=l7 lab=GND}
C {madvlsi/nmos3.sym} 990 20 1 1 {name=M35
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} 990 50 0 1 {name=l8 lab=GND}
C {madvlsi/nmos3.sym} -530 20 3 0 {name=M36
L=32
W=4
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/gnd.sym} -530 50 0 0 {name=l9 lab=GND}
