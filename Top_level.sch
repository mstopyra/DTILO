v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/mstopyra/Documents/FINAL/RING_OSC.sym} 110 0 0 0 {name=x1}
C {/home/mstopyra/Documents/FINAL/FCDA.sym} -180 0 0 0 {name=x2}
C {/home/mstopyra/Documents/FINAL/FCDA_BIAS.sym} -390 -150 0 0 {name=x3}
